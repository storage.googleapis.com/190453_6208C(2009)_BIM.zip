Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-10T06:07:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 10 06:07:06 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{F407E11E-E76F-4EA7-9647-E4A3351D29B6}\ifc * Database version: 5507 * Database creation date: Fri Aug 10 06:07:05 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 10 06:07:06 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 10 06:07:06 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6208C Cover part for washbasin faucet, 12 V, 6208C(2009):6208C Cover part for washbasin faucet, 12 V:336661
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 189 mm; NominalHeight: 199 mm; NominalWidth: 159 mm; Projection: 250 mm
Type - Electrical(Type) - Electrical Connection: 12 VDC; Operating Voltage: 12 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6208C(2009); ConvergoRefNr: 0087-1809-0044-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 08/08/2018
Type - Green Building Properties(Type) - EAN Number: 6414150061455; EMC Directive: 2004/108/EY; EN Standard: EN 15091; ETA-Danmark: VA 1.43/18529; LVI Number: 6116913; Noise Class: I (ISO3822); NRF Number: 4204411; Protection Class: IP 55; RSK Number: 8553422; STF Certificate: VTT-RTH-00025-09; VVS Number: 704290704
Type - Identity Data(Type) - Class: Concealed, separate transformer, touchless; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 6208C Cover part for washbasin faucet, 12 V; Name_en: 6208C Cover part for washbasin faucet, 12 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6208C; Product Datasheet: https://www.oras.com/datasheet/6208C/en; Product Family: Oras Electra; Product URL: https://www.oras.com/en/products/oras/product/6208C; Type Name: 6208C Cover part for washbasin faucet, 12 V; Usage Group: Offices, personnel sanitary facilities;Toilets for the Disabled;Pharmacies, Opticians, Dentists;Health centers & Child welfare clinics;Hospitals;Food stores;Food
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (with magnetic key); Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/109822_PDM_943043_8_(943043-03-17).pdf; Installation Type: Wall mounted concealed; Intelligent After Flow Period: 3 s ± 2 s; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Opening Range: 0 - 5 cm; Pressure Loss With Flow 01ls: 200000 Pa; Recognition Range: 40 cm (40 / 50 cm); Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP6207C/
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom, public & semi-public, health & care; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6208C(2009); Features: Concealed, separate transformer, touchless; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6208C; Name: 6208C Cover part for washbasin faucet, 12 V; ReplacementCost: n/a; Shape: Sculptured; Size: 160x190x200 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6208C; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6208C Cover part for washbasin faucet, 12 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.099303 m2; Volume: 0.00598015 m3
Identity Data - Mark: 12
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6208C(2009): 6208C Cover part for washbasin faucet, 12 V; Family and Type: 6208C(2009): 6208C Cover part for washbasin faucet, 12 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6208C(2009): 6208C Cover part for washbasin faucet, 12 V; Type Id: 6208C(2009): 6208C Cover part for washbasin faucet, 12 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
